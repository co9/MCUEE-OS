# Keil uVision project OS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: OS +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\OS
  group Source Group 1
    ./: STARTUP.A51 main.c core.c core.h
